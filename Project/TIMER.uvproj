# Keil uVision project TIMER.uvproj, settings and files
target ChargingPile (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: TIMER
  c flags: Optim=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Driver\CMSIS\CoreSupport;..\STM32F10x_StdPeriph_Driver\CMSIS\DeviceSupport;..\User\Main
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/Main/: hw_config.c main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c misc.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group CMSIS
    ../STM32F10x_StdPeriph_Driver/CMSIS/CoreSupport/: core_cm3.c
    ../STM32F10x_StdPeriph_Driver/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../STM32F10x_StdPeriph_Driver/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
  group DOC
    ../Doc/: information.txt
